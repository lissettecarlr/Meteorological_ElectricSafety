# Keil uVision project demo.uvprojx, settings and files
target template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\lib\math;..\..\..\lib\onchip\ADC;..\..\..\lib\onchip\capture;..\..\..\lib\onchip\delay;..\..\..\lib\onchip\flash;..\..\..\lib\onchip\GPIO;..\..\..\lib\onchip\I2C;..\..\..\lib\onchip\interrupt;..\..\..\lib\onchip\PWM;..\..\..\lib\onchip\taskManager;..\..\..\lib\onchip\timer;..\..\..\lib\onchip\USART;..\..\..\lib\offchip\LED;.\app;..\..\..\lib\onchip\FreeUsart;..\..\..\lib\offchip\LORA;..\..\..\lib\offchip\rain;..\..\..\lib\offchip\yishan_PM2_5;..\..\..\lib\offchip;..\..\..\lib\protocol\Modbus-RTU;..\..\..\lib\offchip\JDRK_LIGHT;..\..\..\lib\offchip\JDRK_RAIN;..\..\..\lib\offchip\JDRK_TEMP_HUMI;..\..\..\lib\offchip\JDRK_WIND_DIRECTION;..\..\..\lib\offchip\JDRK_WIND_SPEED;..\..\..\lib\offchip\Acrel-ARCM;..\..\..\lib\offchip\TN-water;..\..\..\lib\protocol\weichuan-lora-M100D_P;..\..\..\lib\protocol\slip;..\..\..\lib\onchip\WDG
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib/onchip
    ../../../lib/onchip/ADC/: ADC.cpp
    ../../../lib/onchip/GPIO/: GPIO.cpp
    ../../../lib/onchip/interrupt/: Interrupt.cpp
    ../../../lib/onchip/taskManager/: TaskManager.cpp
    ../../../lib/onchip/timer/: Timer.cpp
    ../../../lib/onchip/USART/: USART.cpp
    ../../../lib/onchip/FreeUsart/: FreeUSART.cpp
    ../../../lib/offchip/LORA/: AT.cpp
    ../../../lib/onchip/WDG/: wdg.cpp
  group lib/offchip
    ../../../lib/offchip/yishan_PM2_5/: yishan_PM2_5.cpp
    ../../../lib/offchip/: IOT_sensor.h
    ../../../lib/offchip/JDRK_LIGHT/: jdrk_light.cpp
    ../../../lib/offchip/JDRK_RAIN/: jdrk_rain.cpp
    ../../../lib/offchip/JDRK_TEMP_HUMI/: jdrk_temp_humi.cpp
    ../../../lib/offchip/JDRK_WIND_DIRECTION/: jdrk_winddirection.cpp
    ../../../lib/offchip/JDRK_WIND_SPEED/: jdrk_windspeed.cpp
    ../../../lib/offchip/HMI/: HMI.cpp
    ../../../lib/offchip/Acrel-ARCM/: Acrel-ARCM.cpp
    ../../../lib/offchip/TN-water/: TN.cpp
  group app
    ./app/: Main.cpp Configuration.h UserInterrupt.cpp
  group protocol
    ../../../lib/protocol/Modbus-RTU/: Modbus-RTU.cpp
    ../../../lib/protocol/weichuan-lora-M100D_P/: weichuan-m100d.cpp
    ../../../lib/protocol/slip/: slip.cpp
software components: CMSIS:CORE 5.0.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
